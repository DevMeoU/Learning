# Keil uVision project main.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L443RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Source Group 1
    ./: main.s fixing.c Learn_MOV_ADD.s Learn_SUB_MLA_MLS_RSB_MUL.s Learn_LSL_LSR_ROTATE.s Learn_Clear_Insert_Bit.s Learn_AND_ORR_BIC_ORN_EOR.s Learn_LDR_STR.s Learn_CMP_Label_B_BL_BX.s IF.s Learn_Switch_Case.s loop.s condition.s Assignment_1.s Assignment_2.s main.c temp.cpp
software components: CMSIS:CORE 6.1.0, Device:Startup 1.3.2
